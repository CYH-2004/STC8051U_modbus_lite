# Keil uVision project STC8051U_modbus_lite.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: STC8051U_modbus_lite +hex
  group Basic
    ./Basic/: Key.c Timer.c Uart1.c Uart2.c Uart3.c iic.c Uart4.c
  group Modbus_lite
    ./Modbus_lite/: modbus.c
  group User
    ./User/: main.c
  group SSD1306
    ./SSD1306/: oled12824_iic.c
